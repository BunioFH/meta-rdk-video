SRC_URI += " \
           file://0666-wrong-name-workaround.patch \
          "
